Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-05-23T22:40:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon May 23 22:40:40 2022 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\{12E287BD-F646-442A-99B9-EBF67AA762F2}\ifc * Database version: 5507 * Database creation date: Mon May 23 22:40:39 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon May 23 22:40:40 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon May 23 22:40:40 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowController: 2606FH(2022) Washbasin faucet, 2606FH(2022):2606FH(2022) Washbasin faucet:12484
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - FaucetNominalDepth: 204.152 mm; FaucetNominalHeight: 197.706 mm; FaucetNominalWidth: 50 mm; HandShowerNominalDepth: 68.2057 mm; HandShowerNominalHeight: 315.44 mm; HandShowerNominalWidth: 45.9 mm; InletConnectionSize: 10 mm
Type - General - Author: BIMstone; BIMObjectName: 2606FH(2022); ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: Washbasin faucet with Bidetta hand shower; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 17/05/2022
Type - Green Building Properties - Backflow Prevention EN1717: HC; EAN Number: 6414150099274; EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Conformity: http://static.oras.com/DoC/2606FH; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/2606FH; Catalog Drawing URL: http://static.oras.com/catdrw/2606FH; Dimension Drawing URL: http://static.oras.com/dimdrw/2606FH; FDV Document URL: http://www.oras.com/datasheet/2606FH/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/2606FH; Group: Washbasin faucet; Interactive AR View URL: https://static.oras.com/AR/2606FH; Item Type: Sales item; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/2606FH; Model: 1012F-102 Washbasin faucet; Name_en: 1012F-102 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1012F-102; Product Family: Oras Optima Style; Product Image URL: http://static.oras.com/image/2606FH; Product URL: http://static.oras.com/2606FH; Technical DataSheet URL: http://www.oras.com/datasheet/2606FH/en; Type Name: 2606FH(2022) Washbasin faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Aerator: Standard aerator;PCA® - constant flow rate regardless of pressure variations; Connection: Flexible inlet pipes; Connection Size: G3/8; Excluded Items: Without pop-up waste; Flow Rate At 300kPa With Flow Controller: 0.000353147 m3/s; Hand Shower: Bidetta hand shower; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Pin shape;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: 30Cartridge; Mounting Holes: 1 hole; Spout Projection: 133 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Adjustable hot water stop (included, retrofittable); Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2606FH(2022); Features: Single-lever;Bidetta; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2606FH(2022); Name: 2606FH(2022) Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:50x144x147 mm / Hand shower: 46x64x286 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0958269 m2; Volume: 0.00288027 m3
Identity Data - Mark: 4
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2606FH(2022): 2606FH(2022) Washbasin faucet; Family and Type: 2606FH(2022): 2606FH(2022) Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2606FH(2022): 2606FH(2022) Washbasin faucet; Type Id: 2606FH(2022): 2606FH(2022) Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
